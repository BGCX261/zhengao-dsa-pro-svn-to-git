# Keil uVision project app.uvproj, settings and files
target app (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: app +hex
  AfterMake: .\make.bat
  AfterMake: ..\link_hex\make.bat
  c flags: Optimize=9 SizeSpeed=1
  c include: .\display;.\main;.\music;.\rtc;.\usb_device;.\fm_receive;.\key;.\aux_fun;.\lib;.\msg;.\iic;.\aux_fun;.\usb_device;.\otp_music
  asm include: .\display;.\main;.\music;.\rtc;.\usb_device;.\fm_receive;.\key;.\aux_fun;.\lib;.\msg;.\iic;.\aux_fun;.\usb_device
  group lib
    ./lib/: app.LIB
  group key
    ./key/: key.c my_IR_key.c Dsa.c tunch_key.c
  group main
    ./lib/: STARTUP.A51 clock.c
    ./music/: dac.c
    ./main/: main.c uart.c
  group display
    ./display/: lcd.c disp.c led.c led_ind_drv.c
  group fm_receive
    ./fm_receive/: fm_receive.c fm_receive_api.c rda5807.c Bk1080.c CL6017.c KT0830EG.c qn8035.c
  group msg
    ./msg/: msgfor_hot.c
  group iic
    ./iic/: iic_api.c iic_io.c
  group music
    ./music/: music.c get_musice_file.c device.c id3.c eq.c
  group aux
    ./aux_fun/: aux_fun.c
  group usb_device
    ./usb_device/: msgfor_usb.c MANUFACTURE.a51
  group rtc
    ./rtc/: rtc_api.c rtc_mode.c rtc_operation.c rtc_ui.c
  group page
    ./lib/: func_usb_device_page.c ac309n_0_cpu_page.c ac309n_1_uart_page.c ac309n_2_spi_page.c ac309n_3_emi_page.c ac309n_4_spi_emi_dma_page.c ac309n_5_iic_page.c ac309n_6_adc_page.c ac309n_7_timer_page.c ac309n_8_io_page.c ac309n_main_page.c func_aux_page.c func_fm_page.c func_irtc_page.c func_music_page.c func_my_printf_page.c
  group info
    ../link_hex/: info.txt
  group otp_decode
    ./otp_decode/: start_music.c otp_music.A51
