# IAR project AC109N_SDK.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\
  ICC8051.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB; SRC\COMMON; SRC\FM; SRC\LINE_IN; SRC\MUSIC; SRC\KEY_MSG; SRC; SRC\RTC; SRC\SPI; SRC\USB_DEVICE; SRC\IIC; SRC\DAC; SRC\UI
  ICC8051.CCDiagSuppress: Pa082
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  A8051.ADefines: SDK_APP
  prebuild: make_lib_debug.bat
  postbuild: make_debug.bat
  XLINK.XclFile: SRC\lnk_base_debug.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: NDEBUG
  A8051.ADefines: SDK_APP; NDEBUG
  prebuild: make_lib_release.bat
  postbuild: make_release.bat
  XLINK.XclFile: SRC\lnk_base_release.xcl
  group (top)
    src/: clock.c lnk_base_debug.xcl lnk_base_release.xcl Log.c main.c uart.c
    link_hex6L/: info.txt
  group common
    src/: AC109N_lib.r51
    src/common/: cd002.s51 cexit.s51 cmain.s51 cstartup.s51 gpio_if.c
  group DAC
    src/DAC/: dac.c
  group fm
    src/fm/: FM_API.c fm_radio.c
  group IIC
    src/IIC/: iic.c
  group key msg
    src/key_msg/: hot_msg.c key.c misc_hdlr_if.c
  group line in
    src/line_in/: blue_tooth_msg_if.c blue_tooth_uart_drv.c bluetooth_mode.c ipod_mode.c Line_in_mode.c
  group music
    src/music/: break_point.c device.c get_musice_file.c music_play.c play_file.c sdmmc.c usb_host.c
  group Page
    src/Page/: adc_page.c clock_page.c cpu_page.c dac_page.c iic_page.c io_page.c irflt_page.c irtc_page.c lcd_page.c Main_page.c spi_emi_dma_page.c spi_page.c timer_page.c uart_page.c wdt_page.c
  group RTC
    src/RTC/: RTC_API.c RTC_Mode.c
  group UI
    src/UI/: LCD.c LCD_SEG_UI_API.c LCD_UI_API.c LED_UI_API.c
  group USB_Device
    src/USB_Device/: USB_Device_Mode.c
